/* Stock-IDF driver integration probe. Emulator only: no microphone or radio. */
#include <stdint.h>
#include <stdio.h>
#include <string.h>
#include "freertos/FreeRTOS.h"
#include "freertos/semphr.h"
#include "freertos/task.h"
#include "driver/spi_master.h"
#include "driver/usb_serial_jtag.h"
#include "esp_check.h"
#include "esp_lcd_io_spi.h"
#include "esp_lcd_panel_io.h"
#include "esp_lcd_panel_ops.h"
#include "esp_lcd_panel_st7789.h"

static uint8_t pixels[240 * 135 * 2];
static uint8_t synthetic_pcm[2560];

static bool color_done(esp_lcd_panel_io_handle_t io,
                       esp_lcd_panel_io_event_data_t *event, void *context)
{
    BaseType_t woken = pdFALSE;
    (void)io;
    (void)event;
    xSemaphoreGiveFromISR((SemaphoreHandle_t)context, &woken);
    return woken == pdTRUE;
}

static void usb_write(const uint8_t *data, unsigned length)
{
    /* IDF's API sends one whole ring item, unlike Arduino's send-up-to loop. */
    while (length) {
        unsigned chunk = length > 128 ? 128 : length;
        configASSERT(usb_serial_jtag_write_bytes(data, chunk, pdMS_TO_TICKS(10000)) == chunk);
        data += chunk;
        length -= chunk;
    }
}

void app_main(void)
{
    SemaphoreHandle_t ready = xSemaphoreCreateBinary();
    configASSERT(ready);
    const spi_bus_config_t bus = {
        .mosi_io_num = 39, .miso_io_num = -1, .sclk_io_num = 40,
        .quadwp_io_num = -1, .quadhd_io_num = -1, .max_transfer_sz = 64,
    };
    ESP_ERROR_CHECK(spi_bus_initialize(SPI3_HOST, &bus, SPI_DMA_DISABLED));
    puts("PROBE:SPI_READY");
    esp_lcd_panel_io_handle_t io;
    const esp_lcd_panel_io_spi_config_t io_config = {
        .cs_gpio_num = 41, .dc_gpio_num = 45, .spi_mode = 0,
        .pclk_hz = 40000000, .trans_queue_depth = 8,
        .lcd_cmd_bits = 8, .lcd_param_bits = 8,
        .on_color_trans_done = color_done, .user_ctx = ready,
    };
    ESP_ERROR_CHECK(esp_lcd_new_panel_io_spi(SPI3_HOST, &io_config, &io));
    puts("PROBE:IO_READY");
    esp_lcd_panel_handle_t panel;
    const esp_lcd_panel_dev_config_t panel_config = {
        .reset_gpio_num = 21, .rgb_ele_order = LCD_RGB_ELEMENT_ORDER_RGB,
        .bits_per_pixel = 16,
    };
    ESP_ERROR_CHECK(esp_lcd_new_panel_st7789(io, &panel_config, &panel));
    ESP_ERROR_CHECK(esp_lcd_panel_reset(panel));
    puts("PROBE:PANEL_RESET");
    ESP_ERROR_CHECK(esp_lcd_panel_init(panel));
    puts("PROBE:PANEL_INIT");
    ESP_ERROR_CHECK(esp_lcd_panel_swap_xy(panel, true));
    ESP_ERROR_CHECK(esp_lcd_panel_set_gap(panel, 40, 52));
    ESP_ERROR_CHECK(esp_lcd_panel_disp_on_off(panel, true));
    const uint16_t palette[] = {0xf800, 0x07e0, 0x001f};
    for (unsigned y = 0; y < 135; y++) {
        for (unsigned x = 0; x < 240; x++) {
            unsigned offset = (y * 240 + x) * 2;
            uint16_t pixel = palette[(x / 15 + y / 15) % 3];
            pixels[offset] = pixel >> 8;
            pixels[offset + 1] = pixel;
        }
    }
    ESP_ERROR_CHECK(esp_lcd_panel_draw_bitmap(panel, 0, 0, 240, 135, pixels));
    configASSERT(xSemaphoreTake(ready, pdMS_TO_TICKS(10000)) == pdTRUE);
    puts("PROBE:LCD_READY");

    usb_serial_jtag_driver_config_t usb = {.tx_buffer_size = 256, .rx_buffer_size = 256};
    ESP_ERROR_CHECK(usb_serial_jtag_driver_install(&usb));
    puts("PROBE:USB_READY");
    char command[8];
    unsigned received = 0;
    while (received < sizeof(command)) {
        int count = usb_serial_jtag_read_bytes(command + received, sizeof(command) - received,
                                               pdMS_TO_TICKS(10000));
        configASSERT(count > 0);
        received += count;
    }
    configASSERT(memcmp(command, "C|2|1|3\n", sizeof(command)) == 0);
    /* Same seven-byte wire header as production, with generated bytes, NOT audio. */
    const uint8_t header[] = {'S', '3', 'V', '1', 'A', 0x00, 0x0a};
    for (unsigned i = 0; i < sizeof(synthetic_pcm); i++) {
        synthetic_pcm[i] = (i * 37 + 11) & 255;
    }
    usb_write(header, sizeof(header));
    usb_write(synthetic_pcm, sizeof(synthetic_pcm));
    ESP_ERROR_CHECK(usb_serial_jtag_wait_tx_done(pdMS_TO_TICKS(10000)));
    puts("PROBE:PASS");
    while (true) { vTaskDelay(pdMS_TO_TICKS(1000)); }
}
